# IAR project stm8l151.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: STM8L15x_StdPeriph_Driver\inc; User; epd\BSP; epd\Fonts
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8l151.hex
  ILINK.IlinkOutputFile: stm8l151.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group STM8L15x_StdPeriph_Driver
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group STM8L15x_StdPeriph_Driver/Epd/BSP
    epd/BSP/: epd2in13.c epd2in13.h epdhardware.c epdhardware.h epdif.c epdif.h epdpaint.c epdpaint.h imagedata.c imagedata.h
  group STM8L15x_StdPeriph_Driver/Epd/Fonts
    epd/Fonts/: font12.c font16.c font20.c font24.c font8.c fonts.h
  group User
    User/: main.c pcf8563_i2c.c user_usart.c
